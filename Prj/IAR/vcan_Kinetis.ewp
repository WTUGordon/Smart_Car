# IAR project vcan_Kinetis.ewp, settings and files
configuration MK66FX18_Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FX1M0xxx18 NXP MK66FX1M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG_MODE; ARM_MATH_CM4; MK66F18; MK66FX18; FPU_USED
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\FatFs; ..\..\Lib\USB
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: vcan_Kinetis.bin
  ILINK.IlinkOutputFile: vcan_Kinetis.out
  ILINK.IlinkIcfFile: config files\vcan_ROM_K66X1M.icf
  ILINK.IlinkAdditionalLibs: ..\..\Lib\CMSIS\iar_cortexM4l_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MK66FX18_Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60FN1M0xxx15 Freescale MK60FN1M0xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; ARM_MATH_CM4; MK66F18; MK66FX18; FPU_USED
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: vcan_Kinetis.srec
  group App
    ../../App/: main.c MK66_conf.c MK66_it.c
    ../../App/Inc/: MK66_conf.h MK66_it.h PORT_cfg.h
  group Board
    ../../Board/src/: 8700_2100.c angle.c beep.c camera.c Car_Init.c control.c direction.c Fuzzy.c infrared.c Interrupt.c key.c LED.C OLED.c OV7725.c SCCB.c simulate.c speed.c TOF10120.c upper_computer.c
    ../../Board/inc/: 8700_2100.h angle.h beep.h camera.h Car_Init.h control.h direction.h Fuzzy.h infrared.h Interrupt.h key.h LED.H OLED.h OV7725.h OV7725_REG.h SCCB.h simulate.h speed.h TOF10120.h upper_computer.h
  group Chip
    ../../Chip/inc/: common.h
    ../../Chip/src/: misc.c MK66_adc.c MK66_dma.c MK66_flexbus.c MK66_ftm.c MK66_gpio.c MK66_i2c.c MK66_mcg.c MK66_PIT.c MK66_port.c MK66_rtc.c MK66_sdhc.c MK66_spi.c MK66_SysTick.c MK66_uart.c MK66_wdog.c vectors.c
    ../../Chip/src/IAR/: startup_MK66FX18.s system_MK66FX18.c
  group LIB/FatFs
    ../../Lib/FatFs/: diskio.c ff.c
